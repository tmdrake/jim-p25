options:
  parameters:
    author: jim-p25
    description: C++ NBFM listen. No ALSA. UDP PCM 23458, UDP FFT 23460. Same graph as app/nbfm_rx.py. Open in Companion, or grcc for a Pi.
    generate_options: no_gui
    id: jim_nbfm_rx
    output_language: python
    run_options: run
    title: jim-p25 NBFM receive
  states: {}

blocks:
- name: audio_gain
  id: variable
  parameters:
    value: '8'
  states: {}
- name: audio_port
  id: variable
  parameters:
    value: '23458'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: audio_scale
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: cutoff
  id: variable
  parameters:
    value: 8e3
  states: {}
- name: device_args
  id: variable
  parameters:
    value: '"hackrf"'
  states: {}
- name: fft_port
  id: variable
  parameters:
    value: '23460'
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '512'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: if_gain
  id: variable
  parameters:
    value: '16'
  states: {}
- name: keep_n
  id: variable
  parameters:
    value: '195'
  states: {}
- name: max_dev
  id: variable
  parameters:
    value: 2.5e3
  states: {}
- name: offset
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: ppm
  id: variable
  parameters:
    value: '0'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: '40000'
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sql_db
  id: variable
  parameters:
    value: '-100'
  states: {}
- name: tau
  id: variable
  parameters:
    value: '750e-6'
  states: {}
- name: trans_width
  id: variable
  parameters:
    value: 3e3
  states: {}
- name: udp_host
  id: variable
  parameters:
    value: '"127.0.0.1"'
  states: {}
- name: f2s
  id: blocks_float_to_short
  parameters:
    scale: audio_scale
  states: {}
- name: fftb
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: gain
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: logp
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_size
  states: {}
- name: mag
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: nbfm
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_rate
    max_dev: max_dev
    quad_rate: quad_rate
    tau: tau
  states: {}
- name: note_rpi
  id: note
  parameters:
    note: 'Raspberry Pi / later SDR: keep UDP, keep RF gain 0, keep the 50 kHz LO offset. Change device_args (hackrf, rtl=0, soapy=0). Drop samp_rate if USB cannot hold 2 Msps. Do not add audio.sink.'
  states: {}
- name: osmo_src
  id: osmosdr_source
  parameters:
    args: device_args
    bb_gain0: if_gain
    corr0: ppm
    freq0: freq + offset
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: skip
  id: blocks_keep_one_in_n
  parameters:
    n: keep_n
    type: complex
  states: {}
- name: sql
  id: analog_simple_squelch_cc
  parameters:
    alpha: '0.01'
    threshold: sql_db
  states: {}
- name: udp_fft
  id: network_udp_sink
  parameters:
    addr: udp_host
    header: '0'
    payloadsize: fft_size * 4
    port: fft_port
    send_eof: 'True'
    type: float
    vlen: fft_size
  states: {}
- name: udp_pcm
  id: network_udp_sink
  parameters:
    addr: udp_host
    header: '0'
    payloadsize: '320'
    port: audio_port
    send_eof: 'True'
    type: short
  states: {}
- name: vec
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: xlat
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-offset'
    decim: int(samp_rate / quad_rate)
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, cutoff, trans_width)
    type: ccf
  states: {}

connections:
- [f2s, '0', udp_pcm, '0']
- [fftb, '0', mag, '0']
- [gain, '0', f2s, '0']
- [logp, '0', udp_fft, '0']
- [mag, '0', logp, '0']
- [nbfm, '0', gain, '0']
- [osmo_src, '0', skip, '0']
- [osmo_src, '0', xlat, '0']
- [skip, '0', vec, '0']
- [sql, '0', nbfm, '0']
- [vec, '0', fftb, '0']
- [xlat, '0', sql, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
