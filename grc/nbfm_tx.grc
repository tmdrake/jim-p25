options:
  parameters:
    author: jim-p25
    description: C++ NBFM transmit from 8 kHz s16le UDP 23459. LO +50 kHz, rotator down so the voice sits on freq. No Python work() source. Pi-ready.
    generate_options: no_gui
    id: jim_nbfm_tx
    output_language: python
    run_options: run
    title: jim-p25 NBFM transmit
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: device_args
  id: variable
  parameters:
    value: '"hackrf,buffers=64"'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: if_gain
  id: variable
  parameters:
    value: '16'
  states: {}
- name: max_dev
  id: variable
  parameters:
    value: 2.5e3
  states: {}
- name: offset
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: ppm
  id: variable
  parameters:
    value: '0'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: '40000'
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: tau
  id: variable
  parameters:
    value: '750e-6'
  states: {}
- name: udp_port
  id: variable
  parameters:
    value: '23459'
  states: {}
- name: import_math
  id: import
  parameters:
    imports: import math
  states: {}
- name: nbfm
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: max_dev
    quad_rate: quad_rate
    tau: tau
  states: {}
- name: note_rpi
  id: note
  parameters:
    note: Feed 8000 Hz s16le PCM to UDP 23459 (320-byte frames). analog.nbfm_tx runs at 40 kHz, then interpolates to samp_rate. RF gain stays 0. On a Pi, keep device_args and IF gain modest.
  states: {}
- name: osmo_sink
  id: osmosdr_sink
  parameters:
    args: device_args
    bb_gain0: '0'
    corr0: ppm
    freq0: freq + offset
    gain0: rf_gain
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: resamp
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(samp_rate / quad_rate)
    type: ccc
  states: {}
- name: rotator
  id: blocks_rotator_cc
  parameters:
    phase_inc: '-2.0 * math.pi * offset / samp_rate'
  states: {}
- name: s2f
  id: blocks_short_to_float
  parameters:
    scale: '32768'
  states: {}
- name: udp_pcm
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: '320'
    port: udp_port
    src_zeros: 'True'
    type: short
  states: {}

connections:
- [nbfm, '0', resamp, '0']
- [resamp, '0', rotator, '0']
- [rotator, '0', osmo_sink, '0']
- [s2f, '0', nbfm, '0']
- [udp_pcm, '0', s2f, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
